# Keil uVision project S_Toggle.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S_Toggle +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\Y_Step_Motor;..\HARDWARE\LED;..\HARDWARE\KEY;..\USER\delay;..\USER\EXTI;..\USER\sys;..\USER;..\USER\sys_run;..\HARDWARE\X_Step_Motor;..\HARDWARE\Z_Step_Motor;..\HARDWARE\Claw_Step_Motor;..\USER\data_process;..\HARDWARE\usart;..\HARDWARE\Command
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group USER
    ../USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../USER/delay/: delay.c
    ../USER/EXTI/: exti.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/X_Step_Motor/: X_Step_Motor.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/Command/: command.c
  group README
    ../README/: README.txt
